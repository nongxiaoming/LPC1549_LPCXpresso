# Keil uVision project project.uvproj, settings and files
target rt-thread_lpc15xx (ARM-ADS)
  device: LPC1549 NXP
  cpu: IRAM(0x02000000-0x02008FFF) IROM(0x0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: rtthread-lpc15xx
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1
  c include: ..\..\libraries\Device\NXP\LPC15xx\Include;..\..\libraries\CMSIS\Include;..\..\drivers;applications;.;..\..\..\..\rt-thread\include;..\..\..\..\rt-thread\libcpu\arm\cortex-m3;..\..\..\..\rt-thread\libcpu\arm\common;..\..\..\..\rt-thread\components\drivers\include;..\..\..\..\rt-thread\components\drivers\include;..\..\..\..\rt-thread\components\finsh
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x2000000 size 0x9000
  link misc: --keep __fsym_* --keep __vsym_*
  group Libraries
    ../../libraries/Device/NXP/LPC15xx/Source/Templates/: system_LPC15xx.c
    ../../libraries/Device/NXP/LPC15xx/Source/Templates/ARM/: startup_LPC15xx.s
  group Drivers
    ../../drivers/: board.c drv_uart.c drv_led.c
  group Applications
    applications/: application.c startup.c
  group Kernel
    ../../../../rt-thread/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M3
    ../../../../rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../../../../rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../../../rt-thread/components/drivers/serial/: serial.c
    ../../../../rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
  group finsh
    ../../../../rt-thread/components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
